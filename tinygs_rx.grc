options:
  parameters:
    generate_options: qt_gui
    id: tinygs_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 433.3e6
  states: {}
- name: lora_bw
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: lora_cr
  id: variable
  parameters:
    value: '5'
  states: {}
- name: lora_sf
  id: variable
  parameters:
    value: '8'
  states: {}
- name: offset
  id: variable
  parameters:
    value: 0.7e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: lora_lora_receiver_0
  id: lora_lora_receiver
  parameters:
    bandwidth: int(lora_bw)
    center_freq: center_freq + offset
    channel_list: '[center_freq]'
    conj: 'False'
    cr: lora_cr-4
    crc: 'True'
    decimation: '1'
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: lora_sf
  states: {}
- name: lora_message_file_sink_0
  id: lora_message_file_sink
  parameters:
    path: /home/dragon/Documents/tiny-gs/lora_test.txt
  states: {state: disabled}
- name: lora_message_socket_sink_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '0'
    port: '40868'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: soapy_airspyhf_source_0
  id: soapy_airspyhf_source
  parameters:
    center_freq: center_freq + offset
    dev_args: airspy=0
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    center_freq0: center_freq + offset
    dc_removal0: 'False'
    driver: airspy
    gain0: '20'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [lora_lora_receiver_0, frames, lora_message_file_sink_0, in]
- [lora_lora_receiver_0, frames, lora_message_socket_sink_0, in]
- [soapy_airspyhf_source_0, '0', lora_lora_receiver_0, '0']
- [soapy_airspyhf_source_0, '0', qtgui_sink_x_0, '0']
- [soapy_custom_source_0, '0', lora_lora_receiver_0, '0']
- [soapy_custom_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
